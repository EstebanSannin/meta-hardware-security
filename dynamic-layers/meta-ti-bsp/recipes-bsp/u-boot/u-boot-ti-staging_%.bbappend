# TI U-Boot (meta-ti-bsp): generic parts only (HWS_UBOOT_FLAVOR = "generic")
require recipes-bsp/u-boot/u-boot-sec-features.inc
