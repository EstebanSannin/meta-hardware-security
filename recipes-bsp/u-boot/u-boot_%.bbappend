# OpenEmbedded Core U-Boot: generic parts only (HWS_UBOOT_FLAVOR = "generic")
require u-boot-sec-features.inc
